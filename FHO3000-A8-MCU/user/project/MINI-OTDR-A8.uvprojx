# Keil uVision project MINI-OTDR-A8.uvprojx, settings and files
target MINI-OTDR-A8-STM32 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FHO3000A-MCU-V2.0 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\inc;..\src;..\..\library\inc;..\..\library\src;..\..\cmsis;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: stm32f10x_it.c main.c MyUart.c delay.c ADC.c KEY.c DAC.C IIC_BUS.c Timer.c GPIO_CTL.c RTC.c OPM.c FREAQ.C
  group Startup
    ../../cmsis/startup/arm/: startup_stm32f10x_hd.s
  group Cmsis
    ../../cmsis/: system_stm32f10x.c core_cm3.c
  group Library
    ../../library/src/: stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_tim.c
software components: CMSIS:CORE 5.0.2
